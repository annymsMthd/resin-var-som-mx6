CONNECTIVITY_FIRMWARES =+ " \
    wpa-supplicant \
    wl18xx-target-scripts \
    wl18xx-firmware \
    ti-wifi-utils \
    bluez5 \
    "

include resin-image.inc

IMAGE_FSTYPES_append_var-som-mx6 = " resinos-img"

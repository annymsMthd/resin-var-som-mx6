# On Variscite SOM mx6 we flash Resin IO on the emmc
INTERNAL_DEVICE_KERNEL_var-som-mx6 = "mmcblk0"

inherit resin-u-boot

UBOOT_KCONFIG_SUPPORT = "1"
#FILESEXTRAPATHS_append_var-som-mx6 := ":${THISDIR}/patches"
#SRC_URI_append_var-som-mx6 = " file://imx6ul-var-dart-integrate-with-resin-configuration.patch"
